# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c OneWire.h OneWire.c LCD1602.h LCD1602.c DS18B20.h DS18B20.c Delay.h Delay.c AT24C02.h AT24C02.c I2C.h I2C.c Key.c Timer0.h Timer0.c Key.h
